# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\HARDWARE\beep;..\HARDWARE\command;..\HARDWARE\PID;..\HARDWARE\motor;..\HARDWARE\ultrasonic;..\HARDWARE\FILTER;..\HARDWARE\servo;..\variable;..\HARDWARE\LED;..\HARDWARE\switch;..\HARDWARE\motor_pwm;..\HARDWARE\encode;..\HARDWARE\key;..\HARDWARE\oled;..\HARDWARE\Time;..\HARDWARE\Time;..\USER;..\HARDWARE\JY901;..\HARDWARE\dictionary;..\HARDWARE\USART3;..\HARDWARE\USART4;..\HARDWARE\QR_num
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/command/: command.c
    ../HARDWARE/PID/: bsp_pid.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/motor_pwm/: M_pwm.c
    ../HARDWARE/ultrasonic/: ult.c
    ../HARDWARE/FILTER/: filter.c
    ../HARDWARE/servo/: servo.c
    ../HARDWARE/encode/: encode.c
    ../HARDWARE/switch/: switch.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Time/: timer.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/JY901/: UART1.c UART2.c
    ../HARDWARE/USART3/: UART3.c
    ../HARDWARE/USART4/: UART4.c
    ../HARDWARE/dictionary/: dictionary.c
  group variable
    ../variable/: variable.c example.txt
  group QR
    ../HARDWARE/QR_num/: qr_num.c
